CFLAGS:append = " -Wno-error=discarded-qualifiers"
