PACKAGECONFIG:remove = "tests"
PTEST_ENABLED = "0"
