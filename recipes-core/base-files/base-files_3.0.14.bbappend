PSEUDO_DISABLED = "1"
