FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://rpi5-net.cfg"
